# Keil uVision project TL2855_Bosch.uvprojx, settings and files
target TL2855_Bosch (6140001::V6.14.1::.\ARMCompiler6.14.1)
  device: R7FA6M4AF3CFM Renesas
  pack: Renesas.RA_DFP.3.6.0
  cpu: IRAM(0x20000000,0x040000) IROM(0,0x100000) IROM2(0x08000000,0x002000) IROM3(0x0100A000,0x300) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: TL2855_Bosch +hex
  AfterMake: cmd /c ""C:\Renesas\RA\sc_v2021-01_fsp_v2.4.0\eclipse\rasc.exe" --gensecurebundle --compiler ARMv6 "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: QE_TOUCH_CONFIGURATION
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wextra -Wmissing-declarations -Wconversion -Wpointer-arith -Wshadow -Waggregate-return -Wfloat-equal
  c include: .\ra;.\ra_cfg;.\ra_gen;.\src;.\GUI\lvgl;.\GUI;.\GUI\lvgl_driver;.\GUI\lv_examples;.\qe_gen
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c hal_entry.h TL2855.code-workspace
  group GUI
    ./GUI/lvgl/src/lv_core/: lv_disp.c lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c
    ./GUI/lvgl/src/lv_draw/: lv_draw.c lv_draw_arc.c lv_draw_basic.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_rect.c lv_draw_triangle.c lv_img_cache.c lv_img_decoder.c
    ./GUI/lvgl/src/lv_font/: lv_font.c lv_font_fmt_txt.c lv_font_roboto_12.c lv_font_roboto_16.c lv_font_roboto_22.c lv_font_roboto_28.c lv_font_unscii_8.c
    ./GUI/lvgl/src/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ./GUI/lvgl/src/lv_misc/: lv_anim.c lv_area.c lv_async.c lv_circ.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_txt.c lv_utils.c
    ./GUI/lvgl/src/lv_objx/: lv_arc.c lv_bar.c lv_btn.c lv_btnm.c lv_calendar.c lv_canvas.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_imgbtn.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_preload.c lv_roller.c lv_slider.c lv_spinbox.c lv_sw.c lv_ta.c lv_table.c lv_tabview.c lv_tileview.c lv_win.c
    ./GUI/lvgl/src/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_nemo.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
    ./GUI/lvgl_driver/: lv_port_disp.c
  group GUI_APP
    ./GUI_APP/: bosch.c fanspd.c fanstate3.c Line_color.c my_font_icon_100.c sleep5.c my_font_icon_B.c my_font_icon_L.c my_font_icon_Filter.c
  group qe_gen
    ./qe_gen/: qe_touch_config.c qe_touch_sample.c
software components: Flex Software:RA Configuration 1.0.0
